# Keil uVision project na_sens.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52810_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.32.1
  cpu: IRAM(0x20000000,0x00006000) IRAM2(0x00800000,0x00006000) IROM(0x00000000,0x00030000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: na_sens
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x800000 size 0x6000
  group Source Group 1
    ./: main.c MAX30100.h ECG_Measure.c ADPD188GG.c
software components: CMSIS Driver Validation:Framework 1.0.0, CMSIS Driver Validation:I2C 1.0.0, CMSIS Driver:I2C:Custom 2.3.0, CMSIS:CORE 5.2.0, CMSIS:RTOS2:Keil RTX5 5.5.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:I2C:Multi-Slave 1.0.1, Device:Startup 8.32.1
